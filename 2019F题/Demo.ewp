# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx1xx Luminary LM3Sx1xx
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Demo.bin
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\Luminary\LM3S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    $EW_DIR$/ARM/lib/Luminary/: driverlib.a
  group src
    ./: buzzer.c FDC2214.c KEY.C lcd_driver.c main.c SoftI2C.C SoftI2C_CFG.C systemInit.c uartGetPut.c ZLG7290.c
  group startup
    ./: startup_ewarm.c
